# Keil uVision project ExtraPoints1_2020.uvprojx, settings and files
target Landtiger (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample +hex
  AfterMake: "C:\Program Files (x86)\Keil_v\ARM\BIN\ElfDwT.exe" !L
  AfterMake: "C:\Program Files (x86)\Keil_v\ARM\ARMCC\bin\fromelf.exe" --i32combined -o !H !L
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: main.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group led
    ./led/: funct_led.c lib_led.c led.h
  group button_EINT
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group labyrinth
    ./labyrinth/: lib_labyrinth.c labyrinth.h
target Open1768 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: sample +hex
  AfterMake: "C:\Program Files (x86)\Keil_v\ARM\BIN\ElfDwT.exe" !L
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: OPEN1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: sample +hex
  AfterMake: "C:\Program Files (x86)\Keil_v\ARM\BIN\ElfDwT.exe" !L
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0
